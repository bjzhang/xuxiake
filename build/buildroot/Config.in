## build/buildroot/package/xuxiake/Config.in
```kconfig
config BR2_PACKAGE_XUXIAKE
	bool "xuxiake"
	help
	  XU xiake operation system

	  https://github.com/bjzhang/xuxiake
```
